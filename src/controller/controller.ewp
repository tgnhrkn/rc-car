# IAR project controller.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_TM4C123_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: C:\ti\TivaWare_C_Series-2.1.4.178\examples\boards\ek-tm4c123gxl\freertos_demo\.; C:\ti\TivaWare_C_Series-2.1.4.178\examples\boards\ek-tm4c123gxl\freertos_demo\..; C:\ti\TivaWare_C_Series-2.1.4.178\examples\boards\ek-tm4c123gxl\freertos_demo\..\..\..\..; C:\ti\TivaWare_C_Series-2.1.4.178\third_party\FreeRTOS\Source\portable\IAR\ARM_CM4F; C:\ti\TivaWare_C_Series-2.1.4.178\third_party\FreeRTOS; C:\ti\TivaWare_C_Series-2.1.4.178\third_party\FreeRTOS\Source\include; C:\ti\TivaWare_C_Series-2.1.4.178\third_party; C:\TI-CMSIS-Devices-8636\TI\LM4F\Include; C:\ti\TivaWare_C_Series-2.1.4.178\inc; ../../../common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: .; ..; ..\..\..\..; ..\..\..\..\third_party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\third_party\FreeRTOS; ..\..\..\..\third_party\FreeRTOS\Source\include; ..\..\..\..\third_party
  OBJCOPY.OOCOutputFile: freertos_demo.bin
  ILINK.IlinkOutputFile: freertos_demo.out
  ILINK.IlinkIcfFile: freertos_demo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../../../../../ti/TivaWare_C_Series-2.1.4.178/driverlib/ewarm/Exe/: driverlib.a
  group Source
    ../drivers/: buttons.c rgb.c
    ./: freertos_demo.c led_task.c startup_ewarm.c switch_task.c
    ../../../../../../../../ti/TivaWare_C_Series-2.1.4.178/third_party/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../../../../../ti/TivaWare_C_Series-2.1.4.178/third_party/FreeRTOS/Source/: list.c queue.c tasks.c
    ../../../../../../../../ti/TivaWare_C_Series-2.1.4.178/third_party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../../../common/pwm/: pwm.c
    ../../../common/lcd/: SSD2119.c
    ../../../common/uart/: uart.c
    ../../../../../../../../ti/TivaWare_C_Series-2.1.4.178/utils/: uartstdio.c ustdlib.c
  group Source/Task
    ./: car.c carqueues.c control.c display.c drive.c steer.c
